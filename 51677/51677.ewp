# IAR project 51677.ewp, settings and files
configuration PIC Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; REV5; DEBUG_CAN; SANTHOSH
  ICCARM.CCIncludePath2: asm; c; iar; include; lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 51677.hex
  postbuild: post-build.bat "$TARGET_BPATH$"
  ILINK.IlinkOutputFile: 51677.out
  ILINK.IlinkIcfFile: iar\K60_PIC.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum_main,2,.checksum_main,4; --define_symbol __checksum_begin_main=0x10002; --define_symbol __checksum_end_main=0x2DFFD; --keep=__checksum_main
  ILINK.IlinkAdditionalLibs: ..\48386\audio_lib.symbols
  ILINK.IlinkProgramEntryLabel: start
configuration PIC (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK26FN2M0xxx18 NXP MK26FN2M0xxx18
  ICCARM.CCDefines: IAR; REV5; SANTHOSH
  ILINK.IlinkIcfFile: C:\phase2_vv_k26_APL\51677\iar\K60_PIC.icf
configuration Fixed Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; DEBUG_CAN; REV5
  ICCARM.CCIncludePath2: asm; c; iar; include
  ICCARM.CCOptStrategy: 1
  prebuild: "pre-build.bat" "$PROJ_DIR$"
  ILINK.IlinkIcfFile: iar\K60_Fixed.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum_main,2,.checksum_main,4; --define_symbol __checksum_begin_main=0x10002; --define_symbol __checksum_end_main=0x2FFFD; --keep=__checksum_main
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    c/: bdm_ww_main.c bdm_ww_main.h event_buffer.c event_buffer.h init.c init.h isr.c isr.h msgWerewolf.c msgWerewolf.h notifications.c notifications.h nv_data.h post.c post.h profiles.c profiles.h state_machine.c state_machine.h sw_manager.c sw_manager.h switches.c switches.h system.c system.h version-from-svn.h
    ./: post-build.bat pre-build.bat
  group drivers/adc
    c/: ad7265.c ad7265.h adc.c adc.h
  group drivers/audio
    c/: audio.c audio.h
  group drivers/buck
    c/: buck.c buck.h buck_test.c
  group drivers/can
    c/: can.c can.h can_debug.c can_debug.h
  group drivers/cpu
    c/: cpu.c cpu.h
  group drivers/dma
    c/: dma.c dma.h
  group drivers/esdhc
    c/: esdhc.c esdhc.h esdhc_def.h
  group drivers/footpedal
    c/: footpedal.c footpedal.h zigbee.c zigbee.h
  group drivers/fpu
    c/: fpu.h
    asm/: fpu_asm.s
  group drivers/ftfe
    c/: ftfe.c ftfe.h
  group drivers/gui
    c/: gui.c gui.h
  group drivers/led
    c/: led.c led.h
  group drivers/lpt
    c/: lpt.c lpt.h
  group drivers/mcg
    c/: mcg.c mcg.h
  group drivers/pit
    c/: pit.c pit.h
  group drivers/psu
    c/: psu.c psu.h
  group drivers/pump
    c/: pump.c pump.h
  group drivers/rcm
    c/: rcm.c rcm.h
  group drivers/rf
    c/: rf.c rf.h
  group drivers/rtc
    c/: rtc.c rtc.h
  group drivers/sensors
    c/: sensors.c sensors.h
  group drivers/systick
    c/: systick.c systick.h
  group drivers/usb
    lib/: ring_buffer.c ring_buffer.h Settings.h usb.c usb.h usb_cdc.c usb_cdc.h usb_descriptor.h usb_reg.h USBFS_device.c
  group drivers/wand
    c/: fuse_blow.c fuse_blow.h legacy_wand.c legacy_wand.h wand.c wand.h
  group drivers/wdog
    c/: wdog.c wdog.h
  group include
    include/: arm_math.h common.h core_cm4.h data_init3.c data_init3.h MK26F18.h MK60F15.h
  group linker
    iar/: K60_Fixed.icf K60_MR_Boot.icf K60_PIC.icf rf20000.board
  group startup
    c/: crc.c crc.h head.h head.s start.c start.h
    asm/: crt0.s
  group temp
    c/: version-from-svn.c
