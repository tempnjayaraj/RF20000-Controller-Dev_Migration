# IAR project 53826.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: IAR
  ICCARM.CCIncludePath2: asm; c; iar; include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 53826.hex
  postbuild: post-build.bat "$TARGET_BPATH$"
  ILINK.IlinkOutputFile: 53826.out
  ILINK.IlinkKeepSymbols: application
  ILINK.IlinkIcfFile: iar\K60_512KB.icf
  ILINK.IlinkExtraOptions: --place_holder __checksum_main,2,.checksum_main,4; --define_symbol __checksum_begin_main=0x412; --keep=__checksum_main
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK26FN2M0xxx18 NXP MK26FN2M0xxx18
  General.FPU2: 4
  ILINK.IlinkIcfFile: C:\phase2_vv_k26_APL\boot\iar\K60_512KB_release.icf
  group (top)
    c/: isr.c isr.h nv_data.h system.c system.h
    ../51677/include/: MK26F18.h
    ./: post-build.bat
  group ftfe
    c/: ftfe.c ftfe.h
  group linker
    ../../K26/boot/iar/: K60_512KB.icf K60_512KB_release.icf
  group startup
    c/: crc.c crc.h start.c start.h
    asm/: crt0.s head.s
  group wdog
    c/: wdog.c wdog.h
