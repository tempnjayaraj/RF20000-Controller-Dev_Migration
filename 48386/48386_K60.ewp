# IAR project 48386_K60.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK26FN2M0xxx18 NXP MK26FN2M0xxx18
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: include; lib; c; iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 48386_K60.hex
  postbuild: post-build.bat "$TARGET_BPATH$" $TARGET_PATH$ $PROJ_DIR$
  ILINK.IlinkOutputFile: 48386_K60.out
  ILINK.IlinkIcfFile: iar\K60_512K_audio_lib.icf
  ILINK.IlinkProgramEntryLabel: lib_init
  group (top)
    ./: audio_lib.symbols post-build.bat sym_export.txt
    include/: copy_init3.c data_init3.c data_init3.h zero_init3.c
    c/: data.c lib.c
    iar/: K60_512K_audio_lib.icf
    lib/: lib.h lib_func.c
